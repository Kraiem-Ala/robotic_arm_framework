Commit message: differantial Inverse Kinematics using Quaternions

File: new_robot/urdf/new_robot.urdf (robot description, URDF)
Before this commit: robot new_robot, 10 links, 9 joints
Joints:
- joint world_to_base_link=: origin (none) -> xyz=0 0 0.5 rpy=0 0 0
